# Keil uVision project J_H_30_proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8BB21F16G-QFN20 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(50000000)
  output: J_H_30_proj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./BLHeli_S SiLabs/: BLHeli_S.asm
